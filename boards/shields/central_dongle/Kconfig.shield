## boards/shields/central_dongle/Kconfig.shield
```kconfig
config SHIELD_CENTRAL_DONGLE
    def_bool $(shields_list_contains,central_dongle)
```
